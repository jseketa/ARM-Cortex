# Keil uVision project 00_blink.uvproj, settings and files
target f1_00_blink (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: 00_blink +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\inc;..\f1libs\inc;..\js_f1_libs\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ../cmsis/: core_cm3.c
  group library
    ../f1libs/src/: stm32f10x_rcc.c stm32f10x_gpio.c
  group startup
    ./src/: main.c
  group source
    ./src/: system_stm32f10x.c startup_stm32f10x.s
